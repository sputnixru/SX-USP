options:
  parameters:
    author: Mikhail Bychek
    category: Custom
    copyright: SPUTNIX Ltd. sputnix.ru.
    description: SPUTNIX USP FEC protocol RX top level example flowgraph
    generate_options: qt_gui
    id: sx_usp
    output_language: python
    realtime_scheduling: '1'
    title: SX USP
  states: {}

blocks:
- name: bps
  id: variable_qtgui_entry
  parameters:
    gui_hint: ':0,4'
    label: 'BPS(need restart):'
    type: int
    value: cfg_bps
  states: {}
- name: carrier
  id: variable_qtgui_entry
  parameters:
    gui_hint: ':0,0'
    label: Carrier
    type: int
    value: '436000000'
  states: {}
- name: carrier_real
  id: variable
  parameters:
    value: carrier - (carrier % 100000) + 50000
  states: {}
- name: carrier_rounded
  id: variable
  parameters:
    value: carrier_real + 100000
  states: {}
- name: cfg_bps
  id: variable_config
  parameters:
    config_file: default.cfg
    option: bps
    section: rf
    type: int
    value: '9600'
    writeback: bps
  states: {}
- name: cfg_carrier
  id: variable_config
  parameters:
    config_file: default.cfg
    option: carrier
    section: rf
    type: real
    value: 437e6
    writeback: carrier
  states: {state: disabled}
- name: cfg_freq_corr_ppm
  id: variable_config
  parameters:
    config_file: default.cfg
    option: freq_corr_ppm
    section: rf
    type: real
    value: '0.0'
    writeback: freq_corr_ppm
  states: {}
- name: cfg_rx_gain
  id: variable_config
  parameters:
    config_file: default.cfg
    option: rx_gain
    section: rf
    type: int
    value: '0'
    writeback: rx_gain
  states: {}
- name: decimation
  id: variable
  parameters:
    value: int(round((sample_rate_rf / bps) / 24))
  states: {}
- name: decimation_demod
  id: variable
  parameters:
    value: '5'
  states: {}
- name: display_signal
  id: variable_qtgui_chooser
  parameters:
    gui_hint: ':0,5'
    label: 'Display signal:'
    label0: RX
    label1: RX filtered
    label2: FM Demod
    label3: FM Demod MM
    num_opts: '4'
    option0: '0'
    option1: '1'
    option2: '2'
    option3: '3'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
  states: {}
- name: freq_corr
  id: variable
  parameters:
    value: 1.0 + freq_corr_ppm * 1e-6
  states: {}
- name: freq_corr_ppm
  id: variable_qtgui_range
  parameters:
    gui_hint: ':0,1'
    label: Frequency correction(ppm)
    start: '-10'
    step: '0.1'
    stop: '10'
    value: cfg_freq_corr_ppm
  states: {}
- name: offset_from_carrier
  id: variable
  parameters:
    value: carrier - carrier_rounded
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: ':0,2'
    label: RX gain
    min_len: '100'
    rangeType: int
    start: '0'
    step: '1'
    stop: '116'
    value: cfg_rx_gain
  states: {}
- name: sample_rate_bb
  id: variable
  parameters:
    value: sample_rate_rf / decimation
  states: {}
- name: sample_rate_bb
  id: variable
  parameters:
    value: '480000'
  states: {state: disabled}
- name: sample_rate_rf
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: samples_per_bit_demod
  id: variable
  parameters:
    value: sample_rate_bb / bps
  states: {}
- name: samples_per_bit_mod
  id: variable
  parameters:
    value: int(round(sample_rate_rf / bps))
  states: {}
- name: sync
  id: variable
  parameters:
    value: '"0101000001110010111101100100101100101101100100001011000111110101"'
  states: {}
- name: view_options_num
  id: variable
  parameters:
    value: '4'
  states: {}
- name: analog_quadrature_demod_cf_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: ((sample_rate_bb / decimation_demod) / bps) / math.pi
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: datetime.utcnow().strftime("%Y-%m-%d-%H-%M-%S") + "-IQ.dat"
    type: complex
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_1
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_keep_m_in_n_0
  id: blocks_keep_m_in_n
  parameters:
    m: '1'
    n: view_options_num
    offset: display_signal
    type: complex
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: decimation_demod
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_packed_to_unpacked_xx_1
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: (1, 1, 1, 1)
    num_inputs: view_options_num
    type: complex
  states: {}
- name: blocks_tagged_stream_multiply_length_0_1
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: 1 / 8.0
    lengthtagname: packet_len4
    type: byte
  states: {}
- name: blocks_tagged_stream_multiply_length_0_3_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: '8'
    lengthtagname: packet_len3
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: sample_rate_rf
    type: complex
  states: {state: disabled}
- name: blocks_unpacked_to_packed_xx_1
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: Orbicraft-Zorkiy_SignalSample.wav
    nchan: '2'
    repeat: 'True'
  states: {state: disabled}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '1024'
    long_form: 'True'
    type: ff
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25 * 0.175 * 0.175
    mu: '0.5'
    omega: samples_per_bit_demod / decimation_demod
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: digital_correlate_access_code_tag_bb_0_0_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: sync
    tagname: syncword
    threshold: '13'
    type: float
  states: {}
- name: epy_module_0
  id: epy_module
  parameters:
    source_code: "import os\n\nscript_path = os.path.dirname(os.path.realpath(__file__))\nos.chdir(script_path)\n\n"
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: firdes.low_pass(1, sample_rate_bb, bps / 2 * 1.25, bps / 32)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter__2ch_rtlsdr_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: offset_from_carrier
    decim: decimation
    samp_rate: sample_rate_rf
    taps: firdes.low_pass(1, sample_rate_rf, sample_rate_bb / 2, sample_rate_bb / 64)
    type: ccf
  states: {}
- name: gpredict_MsgPairToVar_0
  id: gpredict_MsgPairToVar
  parameters:
    target: carrier
  states: {state: disabled}
- name: gpredict_doppler_0
  id: gpredict_doppler
  parameters:
    gpredict_host: 0.0.0.0
    gpredict_port: '4532'
    verbose: 'False'
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: from datetime import datetime
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: decimation_demod * 5
    taps: firdes.low_pass(1, sample_rate_bb, sample_rate_bb / (decimation_demod * 2), sample_rate_bb / (decimation_demod * 8))
    type: fff
  states: {state: disabled}
- name: interp_fir_filter_xxx_0_0
  id: interp_fir_filter_xxx
  parameters:
    interp: decimation_demod
    taps: firdes.low_pass(1, sample_rate_bb, sample_rate_bb / (decimation_demod * 2), sample_rate_bb / (decimation_demod * 8))
    type: fff
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: bps
    decim: '1'
    gain: '1'
    samp_rate: sample_rate_bb / decimation_demod
    type: fir_filter_fff
    width: bps / 4
    win: window.WIN_HAMMING
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    mtu: '10000'
    port: '8001'
    type: TCP_SERVER
  states: {}
- name: osmosdr_source_0_0
  id: osmosdr_source
  parameters:
    args: rtlsdr=0
    bb_gain0: '0'
    dc_offset_mode0: '2'
    freq0: carrier_rounded * freq_corr
    gain0: rx_gain
    gain_mode0: 'False'
    if_gain0: '0'
    iq_balance_mode0: '2'
    sample_rate: sample_rate_rf
    sync: sync
    type: fc32
  states: {}
- name: osmosdr_source_0_0_0
  id: osmosdr_source
  parameters:
    args: soapy=1,driver=lime
    bb_gain0: '0'
    bw0: '1750000'
    dc_offset_mode0: '2'
    freq0: carrier_rounded * freq_corr
    gain0: rx_gain
    gain_mode0: 'False'
    if_gain0: '0'
    sample_rate: sample_rate_rf
    sync: none
    type: fc32
  states: {state: disabled}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len3
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len4
    type: byte
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: sample_rate_bb
    fc: '0'
    fftsize: '8192'
    gui_hint: ':1,3,1,3'
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: sample_rate_bb
    fc: '0'
    fftsize: '8192'
    gui_hint: ':1,0,1,3'
    showports: 'True'
    type: complex
  states: {}
- name: satellites_check_address_0
  id: satellites_check_address
  parameters:
    address: RS13S
    direction: '"from"'
  states: {}
- name: satellites_check_address_0_0
  id: satellites_check_address
  parameters:
    address: RS14S
    direction: '"from"'
  states: {}
- name: satellites_check_address_0_0_0
  id: satellites_check_address
  parameters:
    address: RS15S
    direction: '"from"'
  states: {}
- name: satellites_pdu_to_kiss_0
  id: satellites_pdu_to_kiss
  parameters:
    control_byte: 'True'
    include_timestamp: 'False'
  states: {}
- name: satellites_print_timestamp_0
  id: satellites_print_timestamp
  parameters:
    count: 'True'
    fmt: KISS RX %H:%M:%S.%f
  states: {}
- name: satellites_submit_0
  id: satellites_submit
  parameters:
    latitude: '0'
    longitude: '0'
    noradID: '0'
    source: A0AAA
    url: https://db.satnogs.org/api/telemetry/
  states: {state: disabled}
- name: satellites_submit_0_0
  id: satellites_submit
  parameters:
    latitude: '0'
    longitude: '0'
    noradID: '0'
    source: A0AAA
    url: https://db.satnogs.org/api/telemetry/
  states: {state: disabled}
- name: satellites_submit_0_0_0
  id: satellites_submit
  parameters:
    latitude: '55.693167'
    longitude: '37.347033'
    noradID: '99971'
    source: A0AAA
    url: https://db.satnogs.org/api/telemetry/
  states: {state: disabled}
- name: satellites_submit_0_0_0_0
  id: satellites_submit
  parameters:
    latitude: '0'
    longitude: '0'
    noradID: '0'
    source: A0AAA
    url: http://db.satnogs.sputnix.ru/api/telemetry/
  states: {state: disabled}
- name: satellites_submit_0_0_1
  id: satellites_submit
  parameters:
    latitude: '0'
    longitude: '0'
    noradID: '0'
    source: A0AAA
    url: http://db.satnogs.sputnix.ru/api/telemetry/
  states: {state: disabled}
- name: satellites_submit_0_1
  id: satellites_submit
  parameters:
    latitude: '0'
    longitude: '0'
    noradID: '0'
    source: A0AAA
    url: http://db.satnogs.sputnix.ru/api/telemetry/
  states: {state: disabled}
- name: satellites_varlen_packet_tagger_0
  id: satellites_varlen_packet_tagger
  parameters:
    endianness: gr.GR_MSB_FIRST
    length_field_size: '16'
    mtu: 255 * 8
    packetlen_tag: packet_len4
    syncword_tag: packet_len3
    use_golay: 'False'
  states: {}
- name: sx_usp_rx_0
  id: sx_usp_rx
  parameters:
    mtu: '255'
    pls: '"0010010011001000110101101001110000000110000101110111100010101111"'
  states: {}
- name: sx_usp_rx_0_0
  id: sx_usp_rx
  parameters:
    mtu: '80'
    pls: '"0111000110011101100000111100100101010011010000100010110111111010"'
  states: {}

connections:
- [analog_quadrature_demod_cf_0_0, '0', dc_blocker_xx_0, '0']
- [blocks_float_to_complex_0, '0', blocks_stream_mux_0, '3']
- [blocks_float_to_complex_0_0, '0', blocks_stream_mux_0, '2']
- [blocks_float_to_complex_1, '0', blocks_throttle2_0, '0']
- [blocks_keep_m_in_n_0, '0', qtgui_sink_x_0, '0']
- [blocks_keep_m_in_n_0, '0', qtgui_sink_x_0_0, '0']
- [blocks_keep_one_in_n_0, '0', analog_quadrature_demod_cf_0_0, '0']
- [blocks_null_source_0, '0', blocks_stream_mux_0, '3']
- [blocks_packed_to_unpacked_xx_1, '0', blocks_tagged_stream_multiply_length_0_3_0, '0']
- [blocks_stream_mux_0, '0', blocks_keep_m_in_n_0, '0']
- [blocks_tagged_stream_multiply_length_0_1, '0', pdu_tagged_stream_to_pdu_0, '0']
- [blocks_tagged_stream_multiply_length_0_3_0, '0', satellites_varlen_packet_tagger_0, '0']
- [blocks_throttle2_0, '0', blocks_stream_mux_0, '0']
- [blocks_throttle2_0, '0', fir_filter_xxx_0, '0']
- [blocks_unpacked_to_packed_xx_1, '0', blocks_tagged_stream_multiply_length_0_1, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_1, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_1, '1']
- [dc_blocker_xx_0, '0', low_pass_filter_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_correlate_access_code_tag_bb_0_0_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', interp_fir_filter_xxx_0, '0']
- [digital_correlate_access_code_tag_bb_0_0_0, '0', sx_usp_rx_0, '0']
- [digital_correlate_access_code_tag_bb_0_0_0, '0', sx_usp_rx_0_0, '0']
- [fir_filter_xxx_0, '0', blocks_keep_one_in_n_0, '0']
- [fir_filter_xxx_0, '0', blocks_stream_mux_0, '1']
- [freq_xlating_fir_filter__2ch_rtlsdr_0_0, '0', blocks_file_sink_0, '0']
- [freq_xlating_fir_filter__2ch_rtlsdr_0_0, '0', blocks_stream_mux_0, '0']
- [freq_xlating_fir_filter__2ch_rtlsdr_0_0, '0', fir_filter_xxx_0, '0']
- [gpredict_doppler_0, freq, gpredict_MsgPairToVar_0, inpair]
- [interp_fir_filter_xxx_0, '0', blocks_float_to_complex_0, '0']
- [interp_fir_filter_xxx_0_0, '0', blocks_float_to_complex_0_0, '0']
- [low_pass_filter_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [low_pass_filter_0, '0', interp_fir_filter_xxx_0_0, '0']
- [osmosdr_source_0_0, '0', freq_xlating_fir_filter__2ch_rtlsdr_0_0, '0']
- [osmosdr_source_0_0_0, '0', freq_xlating_fir_filter__2ch_rtlsdr_0_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_packed_to_unpacked_xx_1, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, satellites_pdu_to_kiss_0, in]
- [satellites_check_address_0, ok, satellites_submit_0, in]
- [satellites_check_address_0, ok, satellites_submit_0_1, in]
- [satellites_check_address_0_0, ok, satellites_submit_0_0, in]
- [satellites_check_address_0_0, ok, satellites_submit_0_0_1, in]
- [satellites_check_address_0_0_0, ok, satellites_submit_0_0_0, in]
- [satellites_check_address_0_0_0, ok, satellites_submit_0_0_0_0, in]
- [satellites_pdu_to_kiss_0, out, satellites_check_address_0, in]
- [satellites_pdu_to_kiss_0, out, satellites_check_address_0_0, in]
- [satellites_pdu_to_kiss_0, out, satellites_check_address_0_0_0, in]
- [satellites_pdu_to_kiss_0, out, satellites_print_timestamp_0, in]
- [satellites_print_timestamp_0, out, network_socket_pdu_0, pdus]
- [satellites_varlen_packet_tagger_0, '0', blocks_unpacked_to_packed_xx_1, '0']
- [sx_usp_rx_0, out_msg, pdu_pdu_to_tagged_stream_0, pdus]
- [sx_usp_rx_0_0, out_msg, pdu_pdu_to_tagged_stream_0, pdus]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
