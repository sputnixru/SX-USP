options:
  parameters:
    author: Mikhail Bychek
    copyright: SPUTNIX Ltd. sputnix.ru.
    description: SPUTNIX USP FEC protocol RX
    generate_options: hb
    id: sx_usp_rx
    output_language: python
    title: SX USP rx
  states: {}

blocks:
- name: dec_cc
  id: variable_cc_decoder_def
  parameters:
    framebits: 255 * 8
    k: '7'
    mode: fec.CC_TRUNCATED
    ndim: '0'
    padding: 'True'
    polys: '[79, -109]'
    rate: '2'
    state_end: '-1'
    state_start: '0'
  states: {}
- name: blocks_keep_m_in_n_1_0_0
  id: blocks_keep_m_in_n
  parameters:
    m: mtu - 32 - 2 - 2
    n: mtu - 32
    offset: '4'
    type: byte
  states: {}
- name: blocks_keep_m_in_n_1_0_0_0
  id: blocks_keep_m_in_n
  parameters:
    m: '1'
    n: mtu - 32
    offset: '2'
    type: byte
  states: {}
- name: blocks_keep_m_in_n_1_0_0_0_1
  id: blocks_keep_m_in_n
  parameters:
    m: '1'
    n: mtu - 32
    offset: '3'
    type: byte
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_null_source_0_1
  id: blocks_null_source
  parameters:
    type: byte
  states: {}
- name: blocks_null_source_1
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: blocks_pdu_to_tagged_stream_2_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len3
    type: byte
  states: {}
- name: blocks_stream_mux_1
  id: blocks_stream_mux
  parameters:
    lengths: (1, 1, mtu - 32 - 2 - 2, 255)
    num_inputs: '4'
    type: byte
  states: {}
- name: blocks_stream_mux_2
  id: blocks_stream_mux
  parameters:
    lengths: (64 + mtu * 8 * 2, 255 * 8 * 2)
    type: float
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: byte
  states: {}
- name: blocks_tag_gate_0_1
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: byte
  states: {}
- name: blocks_tagged_stream_multiply_length_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: 1/8.0
    lengthtagname: packet_len
    type: byte
  states: {}
- name: blocks_tagged_stream_multiply_length_0_3_1
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: (mtu - 32 - 2 + 255) / (mtu - 32)
    lengthtagname: packet_len3
    type: byte
  states: {}
- name: blocks_tagged_stream_to_pdu_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len3
    type: byte
  states: {}
- name: blocks_tagged_stream_to_pdu_0_0_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_unpacked_to_packed_xx_0_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: digital_additive_scrambler_bb_0_0
  id: digital_additive_scrambler_bb
  parameters:
    bits_per_byte: '1'
    count: '0'
    len: '7'
    mask: '0xA9'
    reset_tag_key: packet_len
    seed: '0xFF'
  states: {}
- name: digital_correlate_access_code_tag_bb_0_0_0_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: pls
    tagname: syncword1
    threshold: '13'
    type: float
  states: {}
- name: fec_extended_tagged_decoder_0
  id: fec_extended_tagged_decoder
  parameters:
    decoder_list: dec_cc
    lentagname: packet_len
    mtu: mtu
    puncpat: '''11'''
  states: {}
- name: mtu
  id: parameter
  parameters:
    label: MTU
    type: intx
    value: '255'
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: out_msg
    optional: 'True'
    type: message
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}
- name: pls
  id: parameter
  parameters:
    label: PLS code
    type: str
    value: '"0010010011001000110101101001110000000110000101110111100010101111"'
  states: {}
- name: satellites_decode_rs_ccsds_0
  id: satellites_decode_rs_ccsds
  parameters:
    basis: 'True'
    interleave: '1'
  states: {}
- name: satellites_fixedlen_tagger_0_0_0_1
  id: satellites_fixedlen_tagger
  parameters:
    packet_len: 64 + mtu * 8 * 2
    packetlen_tag: packet_len0
    stream_type: float
    syncword_tag: syncword
  states: {}
- name: satellites_fixedlen_tagger_0_0_0_1_0
  id: satellites_fixedlen_tagger
  parameters:
    packet_len: mtu * 8 * 2
    packetlen_tag: packet_len
    stream_type: float
    syncword_tag: syncword1
  states: {}

connections:
- [blocks_keep_m_in_n_1_0_0, '0', blocks_tag_gate_0, '0']
- [blocks_keep_m_in_n_1_0_0_0, '0', blocks_tag_gate_0_1, '0']
- [blocks_keep_m_in_n_1_0_0_0_1, '0', blocks_stream_mux_1, '0']
- [blocks_null_source_0_1, '0', blocks_stream_mux_1, '3']
- [blocks_null_source_1, '0', blocks_stream_mux_2, '1']
- [blocks_pdu_to_tagged_stream_2_0, '0', blocks_keep_m_in_n_1_0_0, '0']
- [blocks_pdu_to_tagged_stream_2_0, '0', blocks_keep_m_in_n_1_0_0_0, '0']
- [blocks_pdu_to_tagged_stream_2_0, '0', blocks_keep_m_in_n_1_0_0_0_1, '0']
- [blocks_stream_mux_1, '0', blocks_tagged_stream_multiply_length_0_3_1, '0']
- [blocks_stream_mux_2, '0', satellites_fixedlen_tagger_0_0_0_1_0, '0']
- [blocks_tag_gate_0, '0', blocks_stream_mux_1, '2']
- [blocks_tag_gate_0_1, '0', blocks_stream_mux_1, '1']
- [blocks_tagged_stream_multiply_length_0, '0', blocks_tagged_stream_to_pdu_0_0_0, '0']
- [blocks_tagged_stream_multiply_length_0_3_1, '0', blocks_tagged_stream_to_pdu_0, '0']
- [blocks_tagged_stream_to_pdu_0, pdus, pad_sink_1, in]
- [blocks_tagged_stream_to_pdu_0_0_0, pdus, blocks_message_debug_0, print_pdu]
- [blocks_tagged_stream_to_pdu_0_0_0, pdus, satellites_decode_rs_ccsds_0, in]
- [blocks_unpacked_to_packed_xx_0_0, '0', blocks_tagged_stream_multiply_length_0, '0']
- [digital_additive_scrambler_bb_0_0, '0', blocks_unpacked_to_packed_xx_0_0, '0']
- [digital_correlate_access_code_tag_bb_0_0_0_0, '0', blocks_stream_mux_2, '0']
- [fec_extended_tagged_decoder_0, '0', digital_additive_scrambler_bb_0_0, '0']
- [pad_source_0, '0', satellites_fixedlen_tagger_0_0_0_1, '0']
- [satellites_decode_rs_ccsds_0, out, blocks_pdu_to_tagged_stream_2_0, pdus]
- [satellites_fixedlen_tagger_0_0_0_1, '0', digital_correlate_access_code_tag_bb_0_0_0_0, '0']
- [satellites_fixedlen_tagger_0_0_0_1_0, '0', fec_extended_tagged_decoder_0, '0']

metadata:
  file_format: 1
